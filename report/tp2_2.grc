options:
  parameters:
    author: ISMAILI ELYAZID
    generate_options: qt_gui
    id: SIM
    output_language: python
    title: Numerisation du signal de la parole
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: m1.length_stream(path)
  states: {}
- name: Nfft
  id: variable
  parameters:
    value: m1.nextpow2(N)
  states: {}
- name: path
  id: variable
  parameters:
    value: '''/home/elyazid/Bureau/audio_16khz.wav'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: tap1
  id: variable_high_pass_filter_taps
  parameters:
    beta: '6.76'
    cutoff_freq: '100'
    gain: '1.0'
    samp_rate: samp_rate
    width: '100'
    win: window.WIN_KAISER
  states: {}
- name: tap2
  id: variable_high_pass_filter_taps
  parameters:
    beta: '6.76'
    cutoff_freq: '100'
    gain: '1.0'
    samp_rate: samp_rate
    width: '100'
    win: window.WIN_KAISER
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: Nfft
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/elyazid/Bureau/audio_tp2_21.wav
    type: float
    vlen: Nfft
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Nfft
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: N
    type: float
    vector: np.zeros(Nfft-N)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: path
    repeat: 'False'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: Nfft
    forward: 'True'
    shift: 'False'
    type: float
    window: window.blackmanharris(Nfft)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: tap1
    type: fff
  states: {}
- name: m1
  id: epy_module
  parameters:
    source_code: "import numpy as np\n\ndef length_stream(Path='/home/elyazid/Bureau/audio_16khz.wav'):\n\treturn len(np.fromfile(Path))\n        \ndef nextpow2(N):\n\tn=0\n\twhile 2**n <N :\n\t\tn=n+1\t\n\treturn 2**n\n        \n    \n\n        \n   \n"
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    taps: tap2
    type: fff
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_insert_x_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [interp_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_vector_insert_x_0, '0']

metadata:
  file_format: 1
